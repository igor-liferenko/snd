# IAR project EVK527-ATMega32U4-usbdevice_audio.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x100
  General.SCCStackSize: 0x200
  General.SCRStackSize: 64
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDiagSuppress: Pe111,Pe550,Pa082
  ICCAVR.newCCIncludePaths: ..; ../conf; ../../../
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm32u4.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../../../lib_mcu/adc/: adc_drv.c
    ../: audio_task.c main.c usb_descriptors.c usb_specific_request.c
    ../../../lib_board/evk_527/: evk_527.c
    ../../../lib_mcu/flash/: flash_drv.s90
    ../../../lib_mcu/power/: power_drv.c
    ../../../modules/scheduler/: scheduler.c
    ../../../lib_mcu/util/: start_boot.c
    ../../../modules/usb/device_chap9/: usb_device_task.c usb_standard_request.c
    ../../../lib_mcu/usb/: usb_drv.c
    ../../../modules/usb/: usb_task.c
